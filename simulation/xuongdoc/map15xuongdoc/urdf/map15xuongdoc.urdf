Commit message: len cau tahng

File: simulation/xuongdoc/map15xuongdoc/urdf/map15xuongdoc.urdf (robot description, URDF)
Before this commit: robot map15xuongdoc, 1 links, 0 joints
Links:
- link base_link: mass 17.3567361745762 -> 27.6102203097526
